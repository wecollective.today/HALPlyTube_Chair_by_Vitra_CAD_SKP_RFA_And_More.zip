Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-12-21T08:36:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 21 08:36:36 2018 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{3B0B96BB-B851-444A-B64C-213C97DA8393}\ifc * Database version: 5507 * Database creation date: Fri Dec 21 08:36:35 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 21 08:36:36 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 21 08:36:36 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: HAL Ply tube, CONV_Vitra_DmstcChrs_HAL_PlyTube:HAL Ply tube:379011
In: Level 1
Material: Wood oak seat
Pset_ManufacturerTypeInformation - ModelReference: 44022100; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.987175 m2; Volume: 0.18122 m3
Materials and Finishes - ChairMainMaterial: Wood oak seat; ChairSecondaryMaterial: Glide white
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_DmstcChrs_HAL_PlyTube: HAL Ply tube; Family and Type: CONV_Vitra_DmstcChrs_HAL_PlyTube: HAL Ply tube; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_DmstcChrs_HAL_PlyTube: HAL Ply tube; Type Id: CONV_Vitra_DmstcChrs_HAL_PlyTube: HAL Ply tube; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_DmstcChrs_HAL_PlyTube; ConvergoRefNr: 0089-1812-0189-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The combination of a plywood seat shell and an understated four-legged base in chrome-plated or powder-coated tubular steel makes HAL Ply Tube one of the most elegant and highly versatile versions in the HAL family of chairs by Jasper Morrison.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Dining chairs; Uniclass2015Reference: Pr_40_50_12_22; Version: 1; VersionDate: 18/12/2018
Identity Data(Type) - Collection: HAL; Cost: 0; Description: The combination of a plywood seat shell and an understated four-legged base in chrome-plated or powder-coated tubular steel makes HAL Ply Tube one of the most elegant and highly versatile versions in the HAL family of chairs by Jasper Morrison.; Designer: Jasper Morrison; Manufacturer: Vitra; Model: HAL Ply tube; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/191068/storage/master/download/FS_HAL_Family-EN.pdf; Type Name: HAL Ply tube; URL: https://www.vitra.com/en-un/living/product/details/hal-ply-tube
Materials and Finishes(Type) - ChairTertiaryMaterial: Chrome
Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_DmstcChrs_HAL_PlyTube; Features: Not stackable.; Finish: Seat shell: plywood (USA). Base: chrome-plated tubular steel, non-stackable. Glides: colour matched to the small attachment parts for the seat shell, choice of white or basic dark. All bases fitted with glides for carpet; felt glides optionally available for hard floors.; Grade: n/a; Material: Plywood & metal; ModelNumber: n/a; ModelReference: 44022100; Name: DmstcChrs_HAL_PlyTube; ReplacementCost: n/a; Shape: Sculptured; Size: 470x485x795 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
